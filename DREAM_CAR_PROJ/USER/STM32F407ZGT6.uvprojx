# Keil uVision project STM32F407ZGT6.uvprojx, settings and files
target STM32F407ZGT6 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(168000000) ELITTLE
  output: DSP_BASICMATH +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,ARM_MATH_CM4,__CC_ARM,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING,__FPU_PRESENT
  c include: ..\USER;..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\LED;..\FWLIB\inc;..\HARDWARE\KEY;..\HARDWARE\TIMER;..\DSP_LIB;..\DSP_LIB\Include;..\MY_MATH\LOCATION;..\MY_MATH\LOOKUP;..\HARDWARE\REMOTE;..\HARDWARE\ADC;..\HARDWARE\MOTOR;..\HARDWARE\VERSION;..\HARDWARE\OLED;..\HARDWARE\encoder;..\HARDWARE\BEEP;..\MY_MATH\MOTION;..\HARDWARE\DataScope_DP;..\COMMUNICATION;..\USER;..\MY_MATH\S_LOOKUP;..\SENSOR\GYRO;..\SENSOR\ULTROSONIC;..\HARDWARE\RELAY;.\main;..\HARDWARE\IIC;..\HARDWARE\MPU6050\eMPL;..\HARDWARE\MPU6050;..\MY_MATH\QUEUE
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: stm32f4xx_it.c system_stm32f4xx.c
    ./main/: main.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/REMOTE/: remote.c
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/ENCODER/: encoder.c
    ../HARDWARE/MOTOR/: motor.c
    ../HARDWARE/OLED/: oled.c
    ../HARDWARE/BEEP/: beep.c
    ../HARDWARE/DataScope_DP/: DataScope_DP.c
    ../HARDWARE/RELAY/: relay.c
    ../HARDWARE/IIC/: myiic.c
    ../HARDWARE/MPU6050/: mpu6050.c
    ../HARDWARE/MPU6050/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group DSP_LIB
    ../DSP_LIB/: arm_cortexM4lf_math.lib
  group SENSOR
    ../SENSOR/ULTROSONIC/: ultrasonic.c
  group MY_MATH
    ../MY_MATH/LOCATION/: location.c
    ../MY_MATH/LOOKUP/: tri_lookup.c
    ../MY_MATH/MOTION/: motion.c
    ../MY_MATH/S_LOOKUP/: s_lookup.c
    ../MY_MATH/QUEUE/: my_queue.c
  group COMMUNICATION
    ../COMMUNICATION/: ros_interface.c
